PR:append = "_edgeai_0"

require rtos-mem-map.inc
