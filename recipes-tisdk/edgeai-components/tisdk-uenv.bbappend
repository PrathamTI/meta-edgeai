FILESEXTRAPATHS:prepend:edgeai := "${THISDIR}/${PN}/edgeai:"
FILESEXTRAPATHS:prepend:adas := "${THISDIR}/${PN}/adas:"

PR:append = "_edgeai_0"
